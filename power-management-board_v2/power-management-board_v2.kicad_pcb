# Repository tmcit-ararobo-2026a/power-management-board

File README.md:

# Power Management Board

[日本語版](./README_jp.md)

A power management board for robot battery monitoring, soft-start control, and drive power cutoff.

## Table of Contents

1. [Overview](#1-overview)
2. [Features](#2-features)
3. [State Machine](#3-state-machine)
4. [Schematic](#4-schematic)
5. [LED Indicators](#5-led-indicators)
6. [CAN Communication](#6-can-communication)
7. [Contributing](#7-contributing)
8. [License](#8-license)

## 1. Overview

This board reduces battery management costs and provides reliable drive power cutoff.
An STM32G431K8T6 controls all onboard functions.

## 2. Features

### Soft-Start Function
Implements a soft-start circuit to reduce inrush current.
A precharge resistor is connected via a relay to charge the capacitors at low current.
After 500 ms of precharging, the main relay turns on, and the precharge relay turns off after 700 ms.

### Current and Voltage Measurement
Measures output current and voltage via ADC with DMA.
Used to monitor battery condition and analyze total robot power consumption.
Over-current detection pins are also monitored.

### Control and Drive Isolation
The control circuit and drive power circuit are electrically isolated using photocouplers.

### Emergency Stop Function
Cuts off drive power using automotive relays.
Supports two cutoff methods:
- Cutoff via an external physical emergency stop switch.
- Cutoff via CAN command controlling relay switching through the STM32 GPIO.

### Bulk Capacitors
Two 2700 uF electrolytic capacitors (UHE1H272MHD) are mounted on the output to suppress motor regenerative voltage and stabilize power during transient current spikes.
Each capacitor is rated for 3.8 A ripple current, providing 7.6 A total ripple current handling.

## 3. State Machine

Output relays are controlled according to the emergency stop state and the capacitor charge state.

## 4. Schematic

## 5. LED Indicators

| Name | Color | Specification |
| :---: | :---: | :--- |
| LED1 | Red | Blinks every 500 ms in the main loop |
| LED4 | Green | Lights up when initialized via CAN |

## 6. CAN Communication

- **Receive:**
  - Initialization config (sets sensor transmission rate and turns on LED4)
  - Remote emergency stop command
- **Transmit:**
  - Sensor data (voltage and current at the configured interval, default 1000 ms)
  - Status data (emergency stop state, remote emergency stop state, and over-current state on change)

## 7. Contributing

Please refer to [CONTRIBUTING.md](./CONTRIBUTING.md).

## 8. License

This repository is licensed under the [MIT License](./LICENSE).

## KiCad design power-management-board_v2/power-management-board_v2.kicad_pcb

Parts:
C2: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4: 2700uf; CP_Radial_D18.0mm_P7.50mm
C5, C6, C7, C8, C11, C12, C13, C14, C19, C20, C21, C29: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10: 10uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C15, C16, C17, C18: 1nf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C22: 0.47uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C23: 10nf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C24, C25: 4.7uf; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C26: 47pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C27: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C28: 4700pf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C30, C31: 47uf; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C32: 220uf; C_Radial_D8.0mm_H7.0mm_P3.50mm
D1: RB088LAM-60; D_SOD-128
D2, D3, D6, D7, D8, D11, D12, D13, D14, D15, D16, D19, D20, D21, D22, D23: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D9, D10: SS2040FL; SOD-123FL
D29, D30: D; D_SMA_Handsoldering
F2: FCC16501ABTP; Fuse_0603_1608Metric_Pad1.05x0.95mm_HandSolder
IC2: TLP7820_TP4,E; SOIC127P1105X220-8N; Manufacturer_Part_Number LM74502QDDFRQ1
IC3: MCP2562; SOIC127P600X175-8N; Mouser Part Number 771-TJA1441AT/0Z
J1, J8: Conn_01x02; AMASS_XT60-M_1x02_P7.20mm_Vertical
J2, J7, J9: Conn_01x02; AMASS_XT60-F_1x02_P7.20mm_Vertical
J3, J4: Conn_01x04; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J5: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J6: Conn_01x02_Pin; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
K1: FBR562ND12-W
L1: 10uH; XAL6060103MEC
Q3, Q4: SSM3K341R; SOT-23
R1: 243k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 16.9k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4: 24k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R9, R10, R16, R35, R36, R37, R38, R39, R42, R43, R44, R45, R46, R48, R49: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 442k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 90.9k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12, R13, R14: 100Ω; RESC11050X120N
R15, R19, R22: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17: 80k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R18, R23, R27, R29, R31, R32, R33, R34, R40, R41: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R20, R21: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R24: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R25: 1.6k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R26, R30, R47: 10Ω; RESC11050X120N
R28: 140k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R50, R51: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1, RV2: 10k; Potentiometer_Bourns_3296W_Vertical
SW1: SW_Push; switch_TVAF06-A020B-R
SW3: SW_SPDT_312; CJS1200A1
TP1, TP2, TP3: TestPoint; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
U1, U5, U8, U9: TLP293; SOIC-4_4.55x2.6mm_P1.27mm
U2: TPS54560BDDA; Texas_R-PDSO-G8_EP2.95x4.9mm_Mask2.4x3.1mm_ThermalVias
U3: STM32G431K8Tx; LQFP-32_7x7mm_P0.8mm
U4: NJM12888F33; SOT-23-5_HandSoldering
U6: CZ3A07; Mouser Part Number 412-CZ3A07
U7: AP7375; SOT-23_Handsoldering

Connections:
+3.3V: C5.1, C8.1, C11.1, C12.1, C13.1, C20.1, C22.1, IC2.8 (VDD2), IC3.5 (VIO), J5.4, R9.1, R10.1, R20.2, R21.2, R32.2, R40.2, R43.1, U3.1 (VDD), U3.15 (VDDA), U3.17 (VDD), U4.5 (VOUT), U6.13 (VDD)
+5V: C6.1, C10.1, IC2.1 (VDD1), R45.1, U7.2 (VOUT)
+5VA: C19.1, C21.1, IC3.3 (VCC), J3.3, J4.3, R42.1, U4.1 (VIN), U4.3 (CONTROL)
+12V: C30.1, C31.1, C32.1, J8.2, L1.2, R27.1, R28.1
+12VA: C2.1, C27.1, D9.1 (K), D29.1 (K), D30.1 (K), J9.2, K1.3 (coil_1), K1.8 (coil_1), R33.1, U1.4, U5.4, U8.1
CANH: IC3.7 (CANH), J3.4, J4.4, R24.1
CANL: IC3.6 (CANL), J3.2, J4.2, SW3.2 (B)
CAN_RX: IC3.4 (RXD), U3.21 (PA11)
CAN_TX: IC3.1 (TXD), U3.22 (PA12)
Current_sensor_VOUT: C23.2, R25.1, U3.5 (PA0)
EN_return: R32.1, U3.20 (PA10), U8.4
GATE_A: R50.1, U1.3
GATE_B: R51.1, U5.3
GND: C3.2, C4.2, C6.2, C9.2, C10.2, D11.1 (K), D12.2 (A), D21.1 (K), D22.1 (K), D23.1 (K), IC2.3 (VIN-), IC2.4 (GND1), J1.1, J2.1, R11.2, R12.2, R13.2, R14.2, R16.1, R17.1, R34.1, U7.3 (GND)
GNDA: C24.2, C25.2, C26.2, C28.2, C30.2, C31.2, C32.2, D1.2 (A), D6.1 (K), D8.1 (K), J7.1, J8.1, R1.2, R8.2, R29.2, U2.7 (GND), U2.9 (GND)
GNDD: C5.2, C7.2, C8.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.1, D2.1 (K), D3.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D19.1 (K), D20.1 (K), IC2.5 (GND2), IC2.6 (VOUT-), IC3.2 (GND), IC3.8 (S), J3.1, J4.1, J5.2, R18.1, R19.1, R22.1, R23.1, RV1.3, RV2.3, SW1.1, TP3.1 (1_1), U1.2, U3.14 (VSSA), U3.16 (VSS), U3.32 (VSS), U4.2 (GND), U5.2, U6.9 (VSS_1), U6.16 (VSS_2), U8.3, U9.3
GNDPWR: C2.2, C27.2, D7.1 (K), J9.1, Q3.2 (S), Q4.2 (S), R3.2, R4.2, R31.1
INPUT_relay: D10.1 (K), J1.2, K1.1 (N.O.), K1.6 (N.O.), R35.1, U9.1
IP: K1.10 (COM), R26.1, R30.1, R47.1, U6.1 (IP)
LED1_(PWMOK): R36.1, U3.7 (PA2)
LED2_(PWMOK): R37.1, U3.8 (PA3)
LED3: R38.1, U3.9 (PA4)
LED4: R39.1, U3.10 (PA5)
NRST: C14.1, SW1.2, U3.4 (PG10)
unnamed: C28.1, R2.2
unnamed: C29.2, D1.1 (K), L1.1, U2.8 (SW)
unnamed: D2.2 (A), R5.2
unnamed: D3.2 (A), R6.2
unnamed: D6.2 (A), R27.2
unnamed: D7.2 (A), R33.2
unnamed: D8.2 (A), R41.2
unnamed: D9.2 (A), R31.2, U8.2
unnamed: D10.2 (A), R34.2, U9.2
unnamed: D11.2 (A), D12.1 (K), R35.2
unnamed: D13.2 (A), R36.2
unnamed: D14.2 (A), R37.2
unnamed: D15.2 (A), R38.2
unnamed: D16.2 (A), R39.2
unnamed: D19.2 (A), R42.2
unnamed: D20.2 (A), R43.2
unnamed: D21.2 (A), R44.2
unnamed: D22.2 (A), R45.2
unnamed: D23.2 (A), R46.2
unnamed: D29.2 (A), K1.9 (coil_2), Q3.3 (D)
unnamed: D30.2 (A), K1.4 (coil_2), Q4.3 (D)
unnamed: IC2.2 (VIN+), R15.1, R16.2, R17.2
unnamed: K1.5 (COM), R26.2, R30.2, R47.2
unnamed: K1.2 (N.C.), R46.1
unnamed: K1.7 (N.C.), R11.1, R12.1, R13.1, R14.1
unnamed: Q3.1 (G), R3.1, R50.2
unnamed: Q4.1 (G), R4.1, R51.2
unnamed: R20.1, RV1.1
unnamed: R21.1, RV2.1
unnamed: R48.2, U1.1
unnamed: R49.2, U5.1
unnamed: R24.2, SW3.1 (A)
unnamed: C29.1, U2.1 (BOOT)
unnamed: C26.1, R2.1, U2.6 (COMP)
unnamed: R7.2, R8.1, U2.3 (EN)
unnamed: R28.2, R29.1, U2.5 (FB)
unnamed: R1.1, U2.4 (RT/CLK)
unnamed: R23.2, U3.31 (PB8)
unnamed: R25.2, U6.12 (VOUT)
unnamed: C9.1, F2.2, U7.1 (VIN)
OCD1: C18.1, R10.2, U3.18 (PA8), U6.11 (OCD2)
OCD2: C17.1, R9.2, U3.19 (PA9), U6.10 (OCD1)
SWCLK: J5.3, U3.24 (PA14)
SWDIO: J5.1, U3.23 (PA13)
UART_RX: J6.2, U3.30 (PB7)
UART_TX: J6.1, U3.29 (PB6)
VCC: C24.1, C25.1, J7.2, R7.1, R41.1, U2.2 (VIN)
VCC_check: R40.1, U3.28 (PB5), U9.4
VOUT: C3.1, C4.1, F2.1, J2.2, R15.2, R44.1, U6.5 (IN)
VREF1: C15.1, R19.2, RV1.2, TP1.1 (1_1), U6.14 (REF1)
VREF2: C16.1, R22.2, RV2.2, TP2.1 (1_1), U6.15 (REF2)
Voltage_sensor_VOUT: C7.1, IC2.7 (VOUT+), R18.2, U3.6 (PA1)
stm32_EN_1: R5.1, R48.1, U3.26 (PB3)
stm32_EN_2: R6.1, R49.1, U3.27 (PB4)

Notes on the sheet:
CANトランシーバー
駆動系電源停止回路
リレー用DCDC
高電流区画
電流センサー
ローパスフィルタ 9.95 kHz
センサー
STM32
内部抵抗
ソフトスタート完了LED
LED
リセットSW

Board: 2 copper layers, 90.0 x 70.0 mm, 134 parts (17 on the bottom side), 78 nets.

File power-management-board_v2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C10,0603,1,10uf,
"C11, C12, C13, C14, C19, C20, C21, C29, C5, C6, C7, C8",0603,12,0.1uf,
"C15, C16, C17, C18",0603,4,1nf,
C2,0603,1,0.1u,
C22,0603,1,0.47uf,
C23,0603,1,10nf,
"C24, C25",1210,2,4.7uf,
C26,0603,1,47pF,
C27,0805,1,10u,
C28,0603,1,4700pf,
"C3, C4",CP_Radial_D18.0mm_P7.50mm,2,2700uf,
"C30, C31",1210,2,47uf,
C32,C_Radial_D8.0mm_H7.0mm_P3.50mm,1,220uf,
C9,0603,1,1uf,
D1,D_SOD-128,1,RB088LAM-60,
"D10, D9",SOD-123FL,2,SS2040FL,
"D11, D12, D13, D14, D15, D16, D19, D2, D20, D21, D22, D23, D3, D6, D7, D8",0603,16,LED,
"D29, D30",D_SMA_Handsoldering,2,D,
F2,0603,1,FCC16501ABTP,
IC2,SOIC127P1105X220-8N,1,"TLP7820_TP4,E",
IC3,SOIC127P600X175-8N,1,MCP2562,
"J1, J8",AMASS_XT60-M_1x02_P7.20mm_Vertical,2,Conn_01x02,
"J2, J7, J9",AMASS_XT60-F_1x02_P7.20mm_Vertical,3,Conn_01x02,
"J3, J4",JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,2,Conn_01x04,
J5,PinHeader_1x04_P2.54mm_Vertical,1,Conn_01x04_Pin,
J6,TestPoint_2Pads_Pitch2.54mm_Drill0.8mm,1,Conn_01x02_Pin,
K1,FBR562ND12-W,1,FBR562ND12-W,
L1,XAL6060103MEC,1,10uH,
"Q3, Q4",SOT-23,2,SSM3K341R,
R1,0603,1,243k,
"R10, R16, R35, R36, R37, R38, R39, R42, R43, R44, R45, R46, R48, R49, R5, R6, R9",0603,17,1k,
"R11, R12, R13, R14",RESC11050X120N,4,100Ω,
"R15, R19, R22",0603,3,100k,
"R18, R23, R27, R29, R31, R32, R33, R34, R40, R41",0603,10,10k,
R2,0603,1,16.9k,
"R20, R21",0603,2,4.7k,
R24,0603,1,120,
R25,0603,1,1.6k,
"R26, R30, R47",RESC11050X120N,3,10Ω,
R28,0603,1,140k,
"R3, R4",0603,2,24k,
"R50, R51",0603,2,470,
R7,0603,1,442k,
R8,0603,1,90.9k,
"RV1, RV2",Potentiometer_Bourns_3296W_Vertical,2,10k,
SW1,switch_TVAF06-A020B-R,1,SW_Push,
SW3,CJS1200A1,1,SW_SPDT_312,
"TP1, TP2, TP3",TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,3,TestPoint,
"U1, U5, U8, U9",SOIC-4_4.55x2.6mm_P1.27mm,4,TLP293,
U2,Texas_R-PDSO-G8_EP2.95x4.9mm_Mask2.4x3.1mm_ThermalVias,1,TPS54560BDDA,
U3,LQFP-32_7x7mm_P0.8mm,1,STM32G431K8Tx,
U4,SOT-23-5_HandSoldering,1,NJM12888F33,
U6,CZ3A07,1,CZ3A07,
U7,SOT-23_Handsoldering,1,AP7375,

## Code that names these connections

File power-management-board.ioc (part):

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Mcu.Name=STM32G431K(6-8-B)Tx
Mcu.Package=LQFP32
Mcu.UserName=STM32G431K8Tx
PA0.Mode=IN1-Single-Ended
PA0.Signal=ADC1_IN1
PA1.Mode=IN2-Single-Ended
PA1.Signal=ADC1_IN2
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=EMS_EN_IN
PA10.Signal=GPIO_Input
PA11.Mode=FDCAN_Activate
PA11.Signal=FDCAN1_RX
PA12.Mode=FDCAN_Activate
PA12.Signal=FDCAN1_TX
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=LED4
PA2.Signal=GPIO_Output
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=LED3
PA3.Signal=GPIO_Output
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=LED2
PA4.Signal=GPIO_Output
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=LED1
PA5.Signal=GPIO_Output
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=OCD1
PA8.Signal=GPIO_Input
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=OCD2
PA9.Signal=GPIO_Input
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=ENABLE
PB3.Signal=GPIO_Output
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=PRECHARGE
PB4.Signal=GPIO_Output
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=NOT_RECEIVING_POWER
PB5.Signal=GPIO_Input
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=128000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log (part)

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2026-03-21 回路図完成
2026-03-22 修正版(非常停止はあとで変更します)
2026-03-23 修正版完成
2026-03-23 仮配置完了
2026-03-24 完成(ビア以外)
2026-03-25 docs:仕様書追加
2026-03-26 docs:Update README.md
2026-04-02 ガーバー
2026-04-03 fix:わかりにくいリファレンス番号を消し、OVOFFなどパット見でわからない言葉を一般化、シルクの隙間を作り可読性向上
2026-04-07 feat:add upstream base-stm32
2026-04-19 feat:ファームウェア作成のためiocファイル追加。ADC設定は途中。
2026-04-28 feat:電流・電圧測定のためADC設定。DMAを有効化してCPU負荷を低減し安定したサンプリングを考えた。
2026-04-28 feat:初期コード生成
2026-04-28 feat:数kHzでサンプリングできれば十分なのでスキャン周期を遅くした
2026-04-28 feat:app用ライブラリ追加
2026-04-28 feat:gn10_can追加
2026-04-28 feat:メイン処理関数追加
2026-04-28 feat:canの割り込みを有効化してNVIC優先順位を下げた
2026-04-28 fix:.history消去
2026-04-28 chore:gitignoreに.historyを追加
2026-04-28 chore:バックアップファイルを除外
2026-04-28 feat:gn10-canを電源管理デバイスの実装があるブランチにチェックアウト
2026-04-28 feat:FDCAN用ドライバ追加
2026-04-28 feat:adc処理をベタ書き
2026-05-05 feat:printfできるように実装し、floatの表示を設定
2026-05-05 feat:adc設定見直し、DMAのリクエストを連続変換モードへ統一
2026-05-05 feat:adc設定
2026-05-05 feat:vscode用書き込みタスクを追加
2026-05-05 feat:ハードウェアで遊んだ
2026-05-05 feat:[WIP]メイン処理を少し実装
2026-05-05 feat:センサの周期をTickで管理
2026-05-05 refactor:変数の配置を整え、パラメータへのアクセス性を向上
2026-05-05 fix:電流に電圧を代入していたので修正
2026-05-05 chore:gn10-canをmainへ切り替え
2026-05-06 fix:ledのピン配置が逆転していたので修正
2026-05-06 feat:遠隔非常停止とCAN通信からの停止処理追加
2026-05-06 fix:EN_INは負論理
2026-05-06 chore:gn10-can更新
2026-05-06 refactor:初期化追加
2026-05-06 fix:fdcanに変更
2026-05-08 feat:遠隔非常停止機能対か
2026-05-08 chore:gn10-canをmainにチェックアウト
2026-05-08 feat:過電流保護の有無をStatusに対か
2026-05-09 fix:gn10-can実装のstatus構造体の比較演算子にバグがあったので修正
2026-05-09 feat:Delay関数はリアルタイム性に欠けるため排除
2026-05-09 docs:余白整理・パラメータを明記
